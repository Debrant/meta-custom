FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}-${PV}:"



COMPATIBLE_MACHINE = "(tiger6)"
